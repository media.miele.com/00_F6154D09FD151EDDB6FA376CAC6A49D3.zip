Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-04-11T08:30:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 11 08:30:23 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\64887489-faff-45f9-a1fb-7ca8fea81179\a3f7557e-3fb8-41cd-bc8a-3a02e1df6d40\ifc * Database version: 5507 * Database creation date: Tue Apr 11 08:30:23 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 11 08:30:23 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 11 08:30:23 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12153770_USA_KFNF9959iDE:38995900_USA_12153770_KFNF9959iDE, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 38995900_USA_12153770_KFNF9959iDE
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 38995900_USA_12153770_KFNF9959iDE
Type - Pset_ProvisionForVoid - Width: 910 mm; Height: 2027 mm; Depth: 610 mm
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Connection_Water_IN, z_Miele_Design_Alusilver
Pset_BuildingElementProxyCommon - sets with these values: 2
